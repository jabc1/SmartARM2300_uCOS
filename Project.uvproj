# Keil uVision project Project.uvproj, settings and files
target Debug_in_ChipFLASH (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  c include: .\ZY_CODE\Head;.\ZY_CODE\ARM;.\USER_CODE;.\uCOSII
  asm include: .\ZY_CODE\ARM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\ZY_CODE\MiniARM2300\inchip.scf
  link misc: --entry 0x00000000
  group uCOSII
    ./uCOSII/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group ZY_CODE
    ./ZY_CODE/ARM/: Os_cpu_c.c Os_cpu_a.s
    ./ZY_CODE/MiniARM2300/: Startup.s VIC_Control.s target.c
  group USER_CODE
    ./USER_CODE/: ISR.c main.c
target Release_in_ChipFLASH (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: Project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __IN_CHIP
  c include: .\ZY_CODE\Head;.\ZY_CODE\ARM;.\USER_CODE;.\uCOSII
  asm define: EN_CRP
  asm include: .\ZY_CODE\ARM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\ZY_CODE\MiniARM2300\inchip.scf
  link misc: --entry 0x00000000
